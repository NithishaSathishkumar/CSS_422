# Keil uVision project final_Project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C1233H6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: final_Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ../: heap_template.s stdlib_template.s svc_template.s timer_template.s
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
